# Keil uVision project iSO-STM32.uvprojx, settings and files
target BLINDGLASS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\mp3;..\..\User\MPU6050\driver\include;..\..\User\MPU6050\driver\eMPL;..\..\User\MPU6050\driver\stm32L;..\..\User\MPU6050\eMPL-hal;..\..\User\MPU6050\mllite;..\..\User\MPU6050\mpl;..\..\User\Key;..\..\User\UltrasonicWave;..\..\User\MPU6050\mpu6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart1.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/Exti/: bsp_exti.c
    ../../User/i2c/: bsp_i2c.c
  group MP3
    ../../User/mp3/: mp3.c
  group MPU_eMPL
    ../../User/MPU6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/MPU6050/driver/stm32L/: log_stm32.c
    ../../User/MPU6050/eMPL-hal/: eMPL_outputs.c
  group MPU_mllite
    ../../User/MPU6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ../../User/MPU6050/mpl/: libmpllib.lib
  group MPU6050
    ../../User/MPU6050/mpu6050/: mpu6050.c bsp_mpu6050.c
  group KEY
    ../../User/Key/: bsp_key.c
  group ultr
    ../../User/UltrasonicWave/: UltrasonicWave.c UltraConfig.c Kalman.c
software components: CMSIS:CORE 4.1.0
